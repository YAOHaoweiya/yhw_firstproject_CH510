# Keil uVision project CH510_DIGITAL_CODE_V1.uvprojx, settings and files
target CH510_DIGITAL_CODE_V1 (6190000::V6.19::ARMCLANG)
  device: -AT32F425F8P7 ArteryTek
  pack: ArteryTek.AT32F425_DFP.2.0.7
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: CH510_DIGITAL_CODE_V1 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: AT32F425F8P7,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\AT32F425_Firmware_Library_Drivers\inc;..\Libraries\CMSIS\cm4\core_support;..\Libraries\CMSIS\cm4\device_support;..\User;..\DeepCool_Driver;..\usbd_class\custom_hid;..\usbd_driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/cm4/device_support/startup/mdk/: startup_at32f425.s
  group CMSIS
    ../Libraries/CMSIS/cm4/device_support/: system_at32f425.c
  group FWLIB
    ../Libraries/AT32F425_Firmware_Library_Drivers/src/: at32f425_acc.c at32f425_adc.c at32f425_can.c at32f425_crc.c at32f425_crm.c at32f425_debug.c at32f425_dma.c at32f425_ertc.c at32f425_exint.c at32f425_flash.c at32f425_gpio.c at32f425_i2c.c at32f425_misc.c at32f425_pwc.c at32f425_scfg.c at32f425_spi.c at32f425_tmr.c at32f425_usart.c at32f425_usb.c at32f425_wdt.c at32f425_wwdt.c
  group USER
    ../User/: at32f425_clock.c at32f425_int.c main.c
  group DOC
    ../: README.md
  group DeepCool_Driver
    ../DeepCool_Driver/: delay.c spi.c tm1668.c tmr2_pwm.c ch510_show.c
  group USBD_CLASS
    ../usbd_class/custom_hid/: custom_hid_class.c custom_hid_desc.c
  group USBD_DRIVER
    ../usbd_driver/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
